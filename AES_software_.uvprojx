# Keil uVision project AES_software_.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: fault-injector
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c utils.c utils.h stdout_USART.c AES.c
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.6.0
